# Copyright 2020-2021 Digi International Inc.

EXTRA_OECMAKE += "-DCOG_HOME_URI=http://127.0.0.1/"
